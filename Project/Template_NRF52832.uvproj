# Keil uVision project Template_NRF52832.uvproj, settings and files
target nRF52832_xxAA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nRF52832_xxAA +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF52 NRF52832_XXAA S132 SOFTDEVICE_PRESENT BOARD_CUSTOM CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> nRF52832_XXAA NRF_CRYPTO_MAX_INSTANCE_COUNT=1 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --c99 --reduce_paths
  c include: C:\Nordic\SDK\components;C:\Nordic\SDK\components\boards;C:\Nordic\SDK\components\libraries\atomic;C:\Nordic\SDK\components\libraries\atomic_fifo;C:\Nordic\SDK\components\libraries\balloc;C:\Nordic\SDK\components\libraries\block_dev;C:\Nordic\SDK\components\libraries\bsp;C:\Nordic\SDK\components\libraries\button;C:\Nordic\SDK\components\libraries\cli;C:\Nordic\SDK\components\libraries\cli\uart;C:\Nordic\SDK\components\libraries\crc16;C:\Nordic\SDK\components\libraries\crc32;C:\Nordic\SDK\components\libraries\crypto;C:\Nordic\SDK\components\libraries\crypto\backend\cc310;C:\Nordic\SDK\components\libraries\crypto\backend\cc310_bl;C:\Nordic\SDK\components\libraries\crypto\backend\cifra;C:\Nordic\SDK\components\libraries\crypto\backend\mbedtls;C:\Nordic\SDK\components\libraries\crypto\backend\micro_ecc;C:\Nordic\SDK\components\libraries\crypto\backend\nrf_hw;C:\Nordic\SDK\components\libraries\crypto\backend\nrf_sw;C:\Nordic\SDK\components\libraries\crypto\backend\oberon;C:\Nordic\SDK\components\libraries\crypto\backend\optiga;C:\Nordic\SDK\components\libraries\csense;C:\Nordic\SDK\components\libraries\csense_drv;C:\Nordic\SDK\components\libraries\delay;C:\Nordic\SDK\components\libraries\ecc;C:\Nordic\SDK\components\libraries\experimental_section_vars;C:\Nordic\SDK\components\libraries\experimental_task_manager;C:\Nordic\SDK\components\libraries\fds;C:\Nordic\SDK\components\libraries\fifo;C:\Nordic\SDK\components\libraries\fstorage;C:\Nordic\SDK\components\libraries\gfx;C:\Nordic\SDK\components\libraries\gpiote;C:\Nordic\SDK\components\libraries\hardfault;C:\Nordic\SDK\components\libraries\hardfault\nrf52;C:\Nordic\SDK\components\libraries\hci;C:\Nordic\SDK\components\libraries\led_softblink;C:\Nordic\SDK\components\libraries\log;C:\Nordic\SDK\components\libraries\log\src;C:\Nordic\SDK\components\libraries\low_power_pwm;C:\Nordic\SDK\components\libraries\mem_manager;C:\Nordic\SDK\components\libraries\memobj;C:\Nordic\SDK\components\libraries\mpu;C:\Nordic\SDK\components\libraries\mutex;C:\Nordic\SDK\components\libraries\pwm;C:\Nordic\SDK\components\libraries\pwr_mgmt;C:\Nordic\SDK\components\libraries\queue;C:\Nordic\SDK\components\libraries\ringbuf;C:\Nordic\SDK\components\libraries\scheduler;C:\Nordic\SDK\components\libraries\sdcard;C:\Nordic\SDK\components\libraries\slip;C:\Nordic\SDK\components\libraries\sortlist;C:\Nordic\SDK\components\libraries\spi_mngr;C:\Nordic\SDK\components\libraries\stack_guard;C:\Nordic\SDK\components\libraries\stack_info;C:\Nordic\SDK\components\libraries\strerror;C:\Nordic\SDK\components\libraries\timer;C:\Nordic\SDK\components\libraries\twi_mngr;C:\Nordic\SDK\components\libraries\twi_sensor;C:\Nordic\SDK\components\libraries\uart;C:\Nordic\SDK\components\libraries\usbd;C:\Nordic\SDK\components\libraries\usbd\class\audio;C:\Nordic\SDK\components\libraries\usbd\class\cdc;C:\Nordic\SDK\components\libraries\usbd\class\cdc\acm;C:\Nordic\SDK\components\libraries\usbd\class\hid;C:\Nordic\SDK\components\libraries\usbd\class\hid\generic;C:\Nordic\SDK\components\libraries\usbd\class\hid\kbd;C:\Nordic\SDK\components\libraries\usbd\class\hid\mouse;C:\Nordic\SDK\components\libraries\usbd\class\msc;C:\Nordic\SDK\components\libraries\util;C:\Nordic\SDK\external\cifra_AES128-EAX;C:\Nordic\SDK\external\fnmatch;C:\Nordic\SDK\external\fprintf;C:\Nordic\SDK\external\mbedtls\include;C:\Nordic\SDK\external\micro-ecc\micro-ecc;C:\Nordic\SDK\external\nrf_cc310\include;C:\Nordic\SDK\external\nrf_oberon;C:\Nordic\SDK\external\nrf_oberon\include;C:\Nordic\SDK\external\nrf_tls\mbedtls\nrf_crypto\config;C:\Nordic\SDK\external\protothreads;C:\Nordic\SDK\external\protothreads\pt-1.4;C:\Nordic\SDK\external\thedotfactory_fonts;C:\Nordic\SDK\external\utf_converter;C:\Nordic\SDK\integration\nrfx;C:\Nordic\SDK\integration\nrfx\legacy;C:\Nordic\SDK\modules\nrfx;C:\Nordic\SDK\modules\nrfx\drivers\include;C:\Nordic\SDK\modules\nrfx\hal;C:\Nordic\SDK\modules\nrfx\mdk;C:\Nordic\SDK\components\toolchain\cmsis\include;.\SRC;.\freertos\source\include;.\freertos\portable\CMSIS\nrf52;.\freertos\portable\ARM\nrf52;.\freertos\config;C:\Nordic\SDK\external\segger_rtt;C:\Nordic\SDK\components\softdevice\common;C:\Nordic\SDK\components\softdevice\s132\headers;C:\Nordic\SDK\components\softdevice\s132\headers\nrf52;C:\Nordic\SDK\components\ble\ble_advertising;C:\Nordic\SDK\components\ble\ble_dtm;C:\Nordic\SDK\components\ble\ble_racp;C:\Nordic\SDK\components\ble\ble_services\ble_ancs_c;C:\Nordic\SDK\components\ble\ble_services\ble_ans_c;C:\Nordic\SDK\components\ble\ble_services\ble_bas;C:\Nordic\SDK\components\ble\ble_services\ble_bas_c;C:\Nordic\SDK\components\ble\ble_services\ble_cscs;C:\Nordic\SDK\components\ble\ble_services\ble_cts_c;C:\Nordic\SDK\components\ble\ble_services\ble_dfu;C:\Nordic\SDK\components\ble\ble_services\ble_dis;C:\Nordic\SDK\components\ble\ble_services\ble_gls;C:\Nordic\SDK\components\ble\ble_services\ble_hids;C:\Nordic\SDK\components\ble\ble_services\ble_hrs;C:\Nordic\SDK\components\ble\ble_services\ble_hrs_c;C:\Nordic\SDK\components\ble\ble_services\ble_hts;C:\Nordic\SDK\components\ble\ble_services\ble_ias;C:\Nordic\SDK\components\ble\ble_services\ble_ias_c;C:\Nordic\SDK\components\ble\ble_services\ble_lbs;C:\Nordic\SDK\components\ble\ble_services\ble_lbs_c;C:\Nordic\SDK\components\ble\ble_services\ble_lls;C:\Nordic\SDK\components\ble\ble_services\ble_nus;C:\Nordic\SDK\components\ble\ble_services\ble_nus_c;C:\Nordic\SDK\components\ble\ble_services\ble_rscs;C:\Nordic\SDK\components\ble\ble_services\ble_rscs_c;C:\Nordic\SDK\components\ble\ble_services\ble_tps;C:\Nordic\SDK\components\ble\common;C:\Nordic\SDK\components\ble\nrf_ble_gatt;C:\Nordic\SDK\components\ble\nrf_ble_qwr;C:\Nordic\SDK\components\ble\peer_manager;C:\Nordic\SDK\components\libraries\atomic_flags;C:\Nordic\SDK\components\ble\nrf_ble_scan
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_CUSTOM CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD nRF52832_XXAA NRF_CRYPTO_MAX_INSTANCE_COUNT=1 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_CUSTOM,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DnRF52832_XXAA,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: C:\Nordic\SDK\components;C:\Nordic\SDK\components\boards;C:\Nordic\SDK\components\drivers_nrf\nrf_soc_nosd;C:\Nordic\SDK\components\libraries\atomic;C:\Nordic\SDK\components\libraries\atomic_fifo;C:\Nordic\SDK\components\libraries\balloc;C:\Nordic\SDK\components\libraries\block_dev;C:\Nordic\SDK\components\libraries\bsp;C:\Nordic\SDK\components\libraries\button;C:\Nordic\SDK\components\libraries\cli;C:\Nordic\SDK\components\libraries\cli\uart;C:\Nordic\SDK\components\libraries\crc16;C:\Nordic\SDK\components\libraries\crc32;C:\Nordic\SDK\components\libraries\crypto;C:\Nordic\SDK\components\libraries\crypto\backend\cc310;C:\Nordic\SDK\components\libraries\crypto\backend\cc310_bl;C:\Nordic\SDK\components\libraries\crypto\backend\cifra;C:\Nordic\SDK\components\libraries\crypto\backend\mbedtls;C:\Nordic\SDK\components\libraries\crypto\backend\micro_ecc;C:\Nordic\SDK\components\libraries\crypto\backend\nrf_hw;C:\Nordic\SDK\components\libraries\crypto\backend\nrf_sw;C:\Nordic\SDK\components\libraries\crypto\backend\oberon;C:\Nordic\SDK\components\libraries\crypto\backend\optiga;C:\Nordic\SDK\components\libraries\csense;C:\Nordic\SDK\components\libraries\csense_drv;C:\Nordic\SDK\components\libraries\delay;C:\Nordic\SDK\components\libraries\ecc;C:\Nordic\SDK\components\libraries\experimental_section_vars;C:\Nordic\SDK\components\libraries\experimental_task_manager;C:\Nordic\SDK\components\libraries\fds;C:\Nordic\SDK\components\libraries\fifo;C:\Nordic\SDK\components\libraries\fstorage;C:\Nordic\SDK\components\libraries\gfx;C:\Nordic\SDK\components\libraries\gpiote;C:\Nordic\SDK\components\libraries\hardfault;C:\Nordic\SDK\components\libraries\hardfault\nrf52;C:\Nordic\SDK\components\libraries\hci;C:\Nordic\SDK\components\libraries\led_softblink;C:\Nordic\SDK\components\libraries\log;C:\Nordic\SDK\components\libraries\log\src;C:\Nordic\SDK\components\libraries\low_power_pwm;C:\Nordic\SDK\components\libraries\mem_manager;C:\Nordic\SDK\components\libraries\memobj;C:\Nordic\SDK\components\libraries\mpu;C:\Nordic\SDK\components\libraries\mutex;C:\Nordic\SDK\components\libraries\pwm;C:\Nordic\SDK\components\libraries\pwr_mgmt;C:\Nordic\SDK\components\libraries\queue;C:\Nordic\SDK\components\libraries\ringbuf;C:\Nordic\SDK\components\libraries\scheduler;C:\Nordic\SDK\components\libraries\sdcard;C:\Nordic\SDK\components\libraries\slip;C:\Nordic\SDK\components\libraries\sortlist;C:\Nordic\SDK\components\libraries\spi_mngr;C:\Nordic\SDK\components\libraries\stack_guard;C:\Nordic\SDK\components\libraries\stack_info;C:\Nordic\SDK\components\libraries\strerror;C:\Nordic\SDK\components\libraries\timer;C:\Nordic\SDK\components\libraries\twi_mngr;C:\Nordic\SDK\components\libraries\twi_sensor;C:\Nordic\SDK\components\libraries\uart;C:\Nordic\SDK\components\libraries\usbd;C:\Nordic\SDK\components\libraries\usbd\class\audio;C:\Nordic\SDK\components\libraries\usbd\class\cdc;C:\Nordic\SDK\components\libraries\usbd\class\cdc\acm;C:\Nordic\SDK\components\libraries\usbd\class\hid;C:\Nordic\SDK\components\libraries\usbd\class\hid\generic;C:\Nordic\SDK\components\libraries\usbd\class\hid\kbd;C:\Nordic\SDK\components\libraries\usbd\class\hid\mouse;C:\Nordic\SDK\components\libraries\usbd\class\msc;C:\Nordic\SDK\components\libraries\util;C:\Nordic\SDK\external\cifra_AES128-EAX;C:\Nordic\SDK\external\fnmatch;C:\Nordic\SDK\external\fprintf;C:\Nordic\SDK\external\mbedtls\include;C:\Nordic\SDK\external\micro-ecc\micro-ecc;C:\Nordic\SDK\external\nrf_cc310\include;C:\Nordic\SDK\external\nrf_oberon;C:\Nordic\SDK\external\nrf_oberon\include;C:\Nordic\SDK\external\nrf_tls\mbedtls\nrf_crypto\config;C:\Nordic\SDK\external\protothreads;C:\Nordic\SDK\external\protothreads\pt-1.4;C:\Nordic\SDK\external\thedotfactory_fonts;C:\Nordic\SDK\external\utf_converter;C:\Nordic\SDK\integration\nrfx;C:\Nordic\SDK\integration\nrfx\legacy;C:\Nordic\SDK\modules\nrfx;C:\Nordic\SDK\modules\nrfx\drivers\include;C:\Nordic\SDK\modules\nrfx\hal;C:\Nordic\SDK\modules\nrfx\mdk;.\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20008000 size 0x8000
  link misc: --diag_suppress 6330
  group Device
    C:/Nordic/SDK/modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
  group Application
    ./SRC/: main.c sdk_config.h service_if.c
  group Board Definition
    C:/Nordic/SDK/components/boards/: boards.c
  group Board Support
    C:/Nordic/SDK/components/libraries/bsp/: bsp.c
  group UTF8/UTF16 converter
    C:/Nordic/SDK/external/utf_converter/: utf.c
  group nRF_Core
    C:/Nordic/SDK/components/libraries/mpu/: nrf_mpu_lib.c
    C:/Nordic/SDK/components/libraries/stack_guard/: nrf_stack_guard.c
  group nRF_Drivers
    C:/Nordic/SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_spi.c nrf_drv_spis.c nrf_drv_swi.c nrf_drv_twi.c nrf_drv_uart.c
    C:/Nordic/SDK/modules/nrfx/hal/: nrf_nvmc.c
    C:/Nordic/SDK/modules/nrfx/soc/: nrfx_atomic.c
    C:/Nordic/SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_comp.c nrfx_gpiote.c nrfx_i2s.c nrfx_lpcomp.c nrfx_pdm.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_swi.c nrfx_systick.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c
    C:/Nordic/SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Drivers_External
    C:/Nordic/SDK/components/libraries/twi_sensor/: nrf_twi_sensor.c
  group nRF_External
    C:/Nordic/SDK/external/thedotfactory_fonts/: orkney24pts.c orkney8pts.c
  group nRF_Libraries
    C:/Nordic/SDK/components/libraries/button/: app_button.c
    C:/Nordic/SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    C:/Nordic/SDK/components/libraries/fifo/: app_fifo.c
    C:/Nordic/SDK/components/libraries/gpiote/: app_gpiote.c
    C:/Nordic/SDK/components/libraries/pwm/: app_pwm.c
    C:/Nordic/SDK/components/libraries/scheduler/: app_scheduler.c
    C:/Nordic/SDK/components/libraries/sdcard/: app_sdcard.c
    C:/Nordic/SDK/components/libraries/uart/: app_uart_fifo.c
    C:/Nordic/SDK/external/cifra_AES128-EAX/: blockwise.c cifra_cmac.c cifra_eax_aes.c eax.c gf128.c modes.c
    C:/Nordic/SDK/components/libraries/crc16/: crc16.c
    C:/Nordic/SDK/components/libraries/crc32/: crc32.c
    C:/Nordic/SDK/components/libraries/fds/: fds.c
    C:/Nordic/SDK/external/fnmatch/: fnmatch.c
    C:/Nordic/SDK/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    C:/Nordic/SDK/components/libraries/hardfault/: hardfault_implementation.c
    C:/Nordic/SDK/components/libraries/hci/: hci_mem_pool.c hci_slip.c hci_transport.c
    C:/Nordic/SDK/components/libraries/led_softblink/: led_softblink.c
    C:/Nordic/SDK/components/libraries/low_power_pwm/: low_power_pwm.c
    C:/Nordic/SDK/components/libraries/mem_manager/: mem_manager.c
    C:/Nordic/SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    C:/Nordic/SDK/components/libraries/atomic/: nrf_atomic.c
    C:/Nordic/SDK/components/libraries/balloc/: nrf_balloc.c
    C:/Nordic/SDK/components/libraries/cli/: nrf_cli.c
    C:/Nordic/SDK/components/libraries/cli/uart/: nrf_cli_uart.c
    C:/Nordic/SDK/components/libraries/csense/: nrf_csense.c
    C:/Nordic/SDK/components/libraries/csense_drv/: nrf_drv_csense.c
    C:/Nordic/SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    C:/Nordic/SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    C:/Nordic/SDK/components/libraries/gfx/: nrf_gfx.c
    C:/Nordic/SDK/components/libraries/memobj/: nrf_memobj.c
    C:/Nordic/SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    C:/Nordic/SDK/components/libraries/queue/: nrf_queue.c
    C:/Nordic/SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    C:/Nordic/SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    C:/Nordic/SDK/components/libraries/sortlist/: nrf_sortlist.c
    C:/Nordic/SDK/components/libraries/spi_mngr/: nrf_spi_mngr.c
    C:/Nordic/SDK/components/libraries/strerror/: nrf_strerror.c
    C:/Nordic/SDK/components/libraries/twi_mngr/: nrf_twi_mngr.c
    C:/Nordic/SDK/components/libraries/slip/: slip.c
    C:/Nordic/SDK/components/libraries/experimental_task_manager/: task_manager.c task_manager_core_keil.s
    C:/Nordic/SDK/components/libraries/timer/: app_timer_freertos.c
    C:/Nordic/SDK/components/libraries/atomic_flags/: nrf_atflags.c
  group nRF_Log
    C:/Nordic/SDK/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    C:/Nordic/SDK/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.1.lib
  group nRF_TLS
    C:/Nordic/SDK/external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_ticket.c ssl_tls.c threading.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    C:/Nordic/SDK/external/nrf_tls/mbedtls/replacements/: asn1write.c ssl_srv.c
  group nRF_micro-ecc
    C:/Nordic/SDK/external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group Core
    C:/Nordic/SDK/components/toolchain/cmsis/dsp/ARM/: arm_cortexM4lf_math.lib
  group FreeRTOS
    ./freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./freertos/portable/CMSIS/nrf52/: port_cmsis_systick.c port_cmsis.c
    ./freertos/portable/ARM/nrf52/: port.c
    ./freertos/source/portable/MemMang/: heap_4.c
    ./freertos/config/: FreeRTOSConfig.h
  group nRF_Segger_RTT
    C:/Nordic/SDK/external/segger_rtt/: SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c SEGGER_RTT.c
  group nRF_SoftDevice
    C:/Nordic/SDK/components/softdevice/common/: nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c nrf_sdh.c
  group nRF_BLE
    C:/Nordic/SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    C:/Nordic/SDK/components/ble/ble_advertising/: ble_advertising.c
    C:/Nordic/SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    C:/Nordic/SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c peer_id.c
    C:/Nordic/SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    C:/Nordic/SDK/components/ble/nrf_ble_scan/: nrf_ble_scan.c
target flash_s132_nrf52_7.0.1_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: s132_nrf52_7.0.1_softdevice.hex +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192 NRF52832_XXAA
  c misc: --c99 --reduce_paths
  c include: C:\Nordic\SDK\components;C:\Nordic\SDK\components\boards;C:\Nordic\SDK\components\libraries\atomic;C:\Nordic\SDK\components\libraries\atomic_fifo;C:\Nordic\SDK\components\libraries\balloc;C:\Nordic\SDK\components\libraries\block_dev;C:\Nordic\SDK\components\libraries\bsp;C:\Nordic\SDK\components\libraries\button;C:\Nordic\SDK\components\libraries\cli;C:\Nordic\SDK\components\libraries\cli\uart;C:\Nordic\SDK\components\libraries\crc16;C:\Nordic\SDK\components\libraries\crc32;C:\Nordic\SDK\components\libraries\crypto;C:\Nordic\SDK\components\libraries\crypto\backend\cc310;C:\Nordic\SDK\components\libraries\crypto\backend\cc310_bl;C:\Nordic\SDK\components\libraries\crypto\backend\cifra;C:\Nordic\SDK\components\libraries\crypto\backend\mbedtls;C:\Nordic\SDK\components\libraries\crypto\backend\micro_ecc;C:\Nordic\SDK\components\libraries\crypto\backend\nrf_hw;C:\Nordic\SDK\components\libraries\crypto\backend\nrf_sw;C:\Nordic\SDK\components\libraries\crypto\backend\oberon;C:\Nordic\SDK\components\libraries\crypto\backend\optiga;C:\Nordic\SDK\components\libraries\csense;C:\Nordic\SDK\components\libraries\csense_drv;C:\Nordic\SDK\components\libraries\delay;C:\Nordic\SDK\components\libraries\ecc;C:\Nordic\SDK\components\libraries\experimental_section_vars;C:\Nordic\SDK\components\libraries\experimental_task_manager;C:\Nordic\SDK\components\libraries\fds;C:\Nordic\SDK\components\libraries\fifo;C:\Nordic\SDK\components\libraries\fstorage;C:\Nordic\SDK\components\libraries\gfx;C:\Nordic\SDK\components\libraries\gpiote;C:\Nordic\SDK\components\libraries\hardfault;C:\Nordic\SDK\components\libraries\hardfault\nrf52;C:\Nordic\SDK\components\libraries\hci;C:\Nordic\SDK\components\libraries\led_softblink;C:\Nordic\SDK\components\libraries\log;C:\Nordic\SDK\components\libraries\log\src;C:\Nordic\SDK\components\libraries\low_power_pwm;C:\Nordic\SDK\components\libraries\mem_manager;C:\Nordic\SDK\components\libraries\memobj;C:\Nordic\SDK\components\libraries\mpu;C:\Nordic\SDK\components\libraries\mutex;C:\Nordic\SDK\components\libraries\pwm;C:\Nordic\SDK\components\libraries\pwr_mgmt;C:\Nordic\SDK\components\libraries\queue;C:\Nordic\SDK\components\libraries\ringbuf;C:\Nordic\SDK\components\libraries\scheduler;C:\Nordic\SDK\components\libraries\sdcard;C:\Nordic\SDK\components\libraries\slip;C:\Nordic\SDK\components\libraries\sortlist;C:\Nordic\SDK\components\libraries\spi_mngr;C:\Nordic\SDK\components\libraries\stack_guard;C:\Nordic\SDK\components\libraries\stack_info;C:\Nordic\SDK\components\libraries\strerror;C:\Nordic\SDK\components\libraries\timer;C:\Nordic\SDK\components\libraries\twi_mngr;C:\Nordic\SDK\components\libraries\twi_sensor;C:\Nordic\SDK\components\libraries\uart;C:\Nordic\SDK\components\libraries\usbd;C:\Nordic\SDK\components\libraries\usbd\class\audio;C:\Nordic\SDK\components\libraries\usbd\class\cdc;C:\Nordic\SDK\components\libraries\usbd\class\cdc\acm;C:\Nordic\SDK\components\libraries\usbd\class\hid;C:\Nordic\SDK\components\libraries\usbd\class\hid\generic;C:\Nordic\SDK\components\libraries\usbd\class\hid\kbd;C:\Nordic\SDK\components\libraries\usbd\class\hid\mouse;C:\Nordic\SDK\components\libraries\usbd\class\msc;C:\Nordic\SDK\components\libraries\util;C:\Nordic\SDK\external\cifra_AES128-EAX;C:\Nordic\SDK\external\fnmatch;C:\Nordic\SDK\external\fprintf;C:\Nordic\SDK\external\mbedtls\include;C:\Nordic\SDK\external\micro-ecc\micro-ecc;C:\Nordic\SDK\external\nrf_cc310\include;C:\Nordic\SDK\external\nrf_oberon;C:\Nordic\SDK\external\nrf_oberon\include;C:\Nordic\SDK\external\nrf_tls\mbedtls\nrf_crypto\config;C:\Nordic\SDK\external\protothreads;C:\Nordic\SDK\external\protothreads\pt-1.4;C:\Nordic\SDK\external\thedotfactory_fonts;C:\Nordic\SDK\external\utf_converter;C:\Nordic\SDK\integration\nrfx;C:\Nordic\SDK\integration\nrfx\legacy;C:\Nordic\SDK\modules\nrfx;C:\Nordic\SDK\modules\nrfx\drivers\include;C:\Nordic\SDK\modules\nrfx\hal;C:\Nordic\SDK\modules\nrfx\mdk;C:\Nordic\SDK\components\toolchain\cmsis\include;.\SRC;.\freertos\source\include;.\freertos\portable\CMSIS\nrf52;.\freertos\portable\ARM\nrf52;.\freertos\config;C:\Nordic\SDK\external\segger_rtt;C:\Nordic\SDK\components\softdevice\common;C:\Nordic\SDK\components\softdevice\s132\headers;C:\Nordic\SDK\components\softdevice\s132\headers\nrf52;C:\Nordic\SDK\components\ble\ble_advertising;C:\Nordic\SDK\components\ble\ble_dtm;C:\Nordic\SDK\components\ble\ble_racp;C:\Nordic\SDK\components\ble\ble_services\ble_ancs_c;C:\Nordic\SDK\components\ble\ble_services\ble_ans_c;C:\Nordic\SDK\components\ble\ble_services\ble_bas;C:\Nordic\SDK\components\ble\ble_services\ble_bas_c;C:\Nordic\SDK\components\ble\ble_services\ble_cscs;C:\Nordic\SDK\components\ble\ble_services\ble_cts_c;C:\Nordic\SDK\components\ble\ble_services\ble_dfu;C:\Nordic\SDK\components\ble\ble_services\ble_dis;C:\Nordic\SDK\components\ble\ble_services\ble_gls;C:\Nordic\SDK\components\ble\ble_services\ble_hids;C:\Nordic\SDK\components\ble\ble_services\ble_hrs;C:\Nordic\SDK\components\ble\ble_services\ble_hrs_c;C:\Nordic\SDK\components\ble\ble_services\ble_hts;C:\Nordic\SDK\components\ble\ble_services\ble_ias;C:\Nordic\SDK\components\ble\ble_services\ble_ias_c;C:\Nordic\SDK\components\ble\ble_services\ble_lbs;C:\Nordic\SDK\components\ble\ble_services\ble_lbs_c;C:\Nordic\SDK\components\ble\ble_services\ble_lls;C:\Nordic\SDK\components\ble\ble_services\ble_nus;C:\Nordic\SDK\components\ble\ble_services\ble_nus_c;C:\Nordic\SDK\components\ble\ble_services\ble_rscs;C:\Nordic\SDK\components\ble\ble_services\ble_rscs_c;C:\Nordic\SDK\components\ble\ble_services\ble_tps;C:\Nordic\SDK\components\ble\common;C:\Nordic\SDK\components\ble\nrf_ble_gatt;C:\Nordic\SDK\components\ble\nrf_ble_qwr;C:\Nordic\SDK\components\ble\peer_manager;C:\Nordic\SDK\components\libraries\atomic_flags
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200018c8 size 0xe7283
  link misc: --diag_suppress 6330
